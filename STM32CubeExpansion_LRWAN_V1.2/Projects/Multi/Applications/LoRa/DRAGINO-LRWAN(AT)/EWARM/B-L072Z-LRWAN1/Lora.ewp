# IAR project Lora.ewp, settings and files
configuration mlm32l07x01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L072xx; USE_B_L072Z_LRWAN1; USE_HAL_DRIVER; REGION_EU868
  ICCARM.CCIncludePath2: ../../inc; ../../../../../../../Drivers/BSP/MLM32L07X01; ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/Third_Party/Lora/Crypto; ../../../../../../../Middlewares/Third_Party/Lora/Mac; ../../../../../../../Middlewares/Third_Party/Lora/Phy; ../../../../../../../Middlewares/Third_Party/Lora/Utilities; ../../../../../../../Middlewares/Third_Party/Lora/Core; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/hts221; ../../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../../Drivers/BSP/B-L072Z-LRWAN1; ../../../../../../../Middlewares/Third_Party/Lora/Mac/region
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lora.bin
  ILINK.IlinkOutputFile: mlm32l07x01.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group B-L072Z-LRWAN1
    ../../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/MLM32L0X01
    ../../../../../../../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/Lora/Core
    ../../../../../../../Middlewares/Third_Party/Lora/Core/: lora-test.c lora.c
  group Middlewares/Lora/Crypto
    ../../../../../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group Middlewares/Lora/Mac
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group Middlewares/Lora/Mac/Regions
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group Middlewares/Lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
  group Projects/End_Node
    ../../src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c vcom.c
  group Projects/EWARM
    ./: startup_stm32l072xx.s
